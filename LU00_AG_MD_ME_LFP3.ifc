Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: cddc3570-4063-44e8-b51f-78b4f793c0ec, NumberOfSaves: 6], CoordinateReference [CoordinateBase: Aktuelle gemeinsam genutzte Koordinaten, ProjectSite: Vorgabe-Grundstück]
Time: 2024-03-08T07:18:32+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.20.70 (DEU) - IFC 23.3.1.0

# IfcSite, LU
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Sonstige - Kategorie: Projektinformationen
ID-Daten - Gebäudebezeichnung: LU00

# IfcBuilding, LU00
LongName: LU00
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen
ID-Daten - Gebäudebezeichnung: LU00

# IfcBuildingStorey: Ebene:Ebene 1, 0m
In: LU00
LongName: 0m; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0m; sets with these values: 2
Sonstige - Familie: Ebene; Familie und Typ: Ebene: Ebene 1; Kategorie: Ebenen; Typ: Ebene 1; Typ-ID: 1899
Abhängigkeiten - Höhe: 0 mm
Bemaßungen - Höhe für Berechnung: 0 mm
ID-Daten - Gebäudegeschoss: yes; Name: 0m; Tragwerk: no
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Grafiken(Type) - Farbe: 0; Linienmuster: Kompakt; Linienstärke: 1; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
ID-Daten(Type) - Typname: Ebene 1

# IfcBuildingElementProxy: Koordinations-Pyramide:Koordinations-Pyramide (94)
In: 0m
Type - Material: <Unnamed>
Type - Sonstige - Kategorie: Allgemeines Modell; Familienname: Koordinations-Pyramide
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 mm
Type - ID-Daten - Name: Koordinations-Pyramide; Typname: Koordinations-Pyramide
Type - Pset_ProductRequirements - Name: Koordinations-Pyramide
Pset_BuildingElementProxyCommon - Reference: Koordinations-Pyramide; sets with these values: 2
AV_Daten - AV_KATEGORIE: LFP3
Sonstige - AV_KATEGORIE: LFP3; Familie: Koordinations-Pyramide; Familie und Typ: Koordinations-Pyramide: Koordinations-Pyramide; Typ: Koordinations-Pyramide; Typ-ID: 3545
Abhängigkeiten - Basisbauteil: Keine; Verschieben mit umliegenden Elementen: no
Phasen - Phase erstellt: Neue Konstruktion
Name (Koordinations-Pyramide:Koordinations-Pyramide:...) | AV_Daten, AV_NUMMER = Sonstige, AV_NUMMER | AV_Daten, AV_E_COORD = Sonstige, AV_E_COORD | AV_Daten, AV_N_COORD = Sonstige, AV_N_COORD | AV_Daten, AV_HOEHE = Sonstige, AV_HOEHE | AV_Daten, AV_PUNKTZEICHEN = Sonstige, AV_PUNKTZEICHEN | Höhe von Ebene (mm) = Versatz von Host (mm) | Fläche (m2) | Volumen (m3)
5070 | 31121838 | 2664849.966 | 1212420.473 | 454.249 | Bolzen | 454249 | 1.93828 | 0.335389
5071 | 31121841 | 2664833.005 | 1212458.133 | 454.741 | Bolzen | 454741 | 1.92064 | 0.335271
5072 | 31121836 | 2664960.777 | 1212415.336 | 450.544 | Bolzen | 450544 | 1.92615 | 0.335302
5073 | 31122575 | 2664957.345 | 1212436.857 | 439.978 | Bolzen | 439978 | 1.9331 | 0.335343
5074 | 31121835 | 2665044.044 | 1212456.397 | 447.617 | Bolzen | 447617 | 1.9242 | 0.335294
5075 | 31121269 | 2665060.524 | 1212409.199 | 454.994 | Bolzen | 454994 | 1.93952 | 0.335396
5076 | 31121690 | 2665149.594 | 1212441.254 | 453.92 | Bolzen | 453920 | 1.92048 | 0.335271
5077 | 31122906 | 2665251.114 | 1212447.913 | 459.303 | Bolzen | 459303 | 1.92197 | 0.335274
5078 | 31121594 | 2665765.947 | 1212410.234 | 480.314 | Bolzen | 480314 | 1.92315 | 0.335286
5079 | 31121593 | 2665744.468 | 1212443.616 | 477.856 | Bolzen | 477856 | 1.92842 | 0.335319
5080 | 31124057 | 2664817.446 | 1212502.969 | 454.279 | Bolzen | 454279 | 1.93167 | 0.335342
5081 | 31122576 | 2665018.678 | 1212512.374 | 428.33 | Bolzen | 428330 | 1.91717 | 0.33524
5082 | 31121834 | 2665127.093 | 1212506.556 | 444.964 | Bolzen | 444964 | 1.93393 | 0.335356
5083 | 31121691 | 2665238.381 | 1212485.492 | 453.077 | 0 | 453077 | 1.92676 | 0.335304
5084 | 31121692 | 2665375.084 | 1212504.067 | 452.624 | 0 | 452624 | 1.9345 | 0.335358
5085 | 31123003 | 2665534.381 | 1212470.325 | 461.887 | 0 | 461887 | 1.9284 | 0.335315
5086 | 31122262 | 2665623.092 | 1212471.824 | 460.67 | 0 | 460670 | 1.92422 | 0.33529
5087 | 31122883 | 2665660.564 | 1212485.525 | 463.564 | Bolzen | 463564 | 1.94923 | 0.335455
5088 | 31122992 | 2665687.98 | 1212511.572 | 467.229 | 0 | 467229 | 1.92159 | 0.335268
5089 | 31122991 | 2665766.368 | 1212528.666 | 466.174 | 0 | 466174 | 1.93971 | 0.335388
5090 | 31124111 | 2665794.281 | 1212516.298 | 461.321 | Bolzen | 461321 | 1.91295 | 0.335215
5091 | 31122577 | 2664859.197 | 1212537.313 | 432.81 | 0 | 432810 | 1.90776 | 0.335174
5092 | 31124174 | 2664832.436 | 1212588.847 | 433.65 | Bolzen | 433650 | 1.92325 | 0.335287
5093 | 31122681 | 2664918.51 | 1212542.155 | 430.111 | 0 | 430111 | 1.90486 | 0.335165
5094 | 31122590 | 2665132.724 | 1212577.402 | 425.272 | 0 | 425272 | 1.92182 | 0.335268
5095 | 31121833 | 2665209.682 | 1212555.455 | 444.184 | Bolzen | 444184 | 1.93619 | 0.335371
5096 | 31122349 | 2665356.958 | 1212570.157 | 444.729 | Bolzen | 444729 | 1.93086 | 0.33533
5097 | 31122511 | 2665536.037 | 1212588.534 | 451.969 | Bolzen | 451969 | 1.93152 | 0.335333
5098 | 31122711 | 2665588.372 | 1212549.695 | 461.438 | 0 | 461438 | 1.92866 | 0.335316
5099 | 31122964 | 2665660.574 | 1212567.126 | 471.196 | 0 | 471196 | 1.92733 | 0.335307
5100 | 31122736 | 2664919.553 | 1212132.977 | 479.83 | 0 | 479830 | 1.91384 | 0.335214
5101 | 31124139 | 2664958.398 | 1212105.334 | 463.865 | Bolzen | 463865 | 1.93868 | 0.335385
5102 | 31122574 | 2665210.039 | 1212109.422 | 463.312 | 0 | 463312 | 1.92439 | 0.335289
5103 | 31121988 | 2665294.333 | 1212109.965 | 481.811 | Bolzen | 481811 | 1.92898 | 0.335322
5104 | 31121136 | 2665392.821 | 1212112.475 | 476.088 | Bolzen | 476088 | 1.91891 | 0.335252
5105 | 31124158 | 2665415.87 | 1212113.138 | 477.323 | Bolzen | 477323 | 1.90133 | 0.335136
5106 | 31121165 | 2665475.899 | 1212127.359 | 479.943 | 0 | 479943 | 1.92522 | 0.335291
5107 | 31121787 | 2665751.708 | 1212112.403 | 496.389 | 0 | 496389 | 1.91784 | 0.335245
5108 | 31124124 | 2665720.158 | 1212137.664 | 495.236 | Bolzen | 495236 | 1.92477 | 0.335292
5109 | 31122634 | 2665722.189 | 1212138.526 | 495.467 | 0 | 495467 | 1.93163 | 0.335335
5110 | 31124147 | 2664842.897 | 1212165.016 | 480.138 | 0 | 480138 | 1.92405 | 0.335295
5111 | 31122737 | 2664903.991 | 1212179.032 | 486.319 | 0 | 486319 | 1.92362 | 0.335281
5112 | 31121277 | 2665023.373 | 1212160.67 | 479.181 | 0 | 479181 | 1.90141 | 0.335133
5113 | 31121735 | 2665023.151 | 1212200.757 | 480.407 | 0 | 480407 | 1.91635 | 0.335235
5114 | 31121276 | 2665140.58 | 1212197.021 | 470.753 | 0 | 470753 | 1.90449 | 0.335158
5115 | 31121194 | 2665250.716 | 1212194.027 | 461.075 | Bolzen | 461075 | 1.91417 | 0.335223
5116 | 31121135 | 2665378.634 | 1212154.918 | 475.936 | Bolzen | 475936 | 1.92265 | 0.335275
5117 | 31122346 | 2665498.586 | 1212199.127 | 477.906 | 0 | 477906 | 1.93213 | 0.33534
5118 | 31124140 | 2665609.662 | 1212161.444 | 485.075 | 0 | 485075 | 1.93024 | 0.335337
5119 | 31121161 | 2665667.076 | 1212171.652 | 489.502 | Bolzen | 489502 | 1.91934 | 0.335254
5120 | 31121648 | 2665707.877 | 1212184.789 | 494.964 | Bolzen | 494964 | 1.92629 | 0.335306
5121 | 31121156 | 2665756.194 | 1212191.781 | 501.412 | 0 | 501412 | 1.9069 | 0.335174
5122 | 31121642 | 2665676.635 | 1212302.23 | 484.849 | 0 | 484849 | 1.92832 | 0.335318
5123 | 31121414 | 2664816.345 | 1212395.414 | 456.11 | 0 | 456110 | 1.9062 | 0.335179
5124 | 31121270 | 2664949.782 | 1212356.572 | 455.572 | Bolzen | 455572 | 1.92699 | 0.335302
5125 | 31121732 | 2665098.876 | 1212338.903 | 469.873 | 0 | 469873 | 1.9362 | 0.335363
5126 | 31122909 | 2665110.87 | 1212347.768 | 468.22 | 0 | 468220 | 1.91032 | 0.3352
5127 | 31122908 | 2665123.515 | 1212378.737 | 464.992 | Bolzen | 464992 | 1.9278 | 0.335307
5128 | 31123004 | 2665473.51 | 1212396.532 | 457.415 | 0 | 457415 | 1.91552 | 0.33523
5129 | 31124167 | 2665533.197 | 1212352.431 | 461.184 | 0 | 461184 | 1.9145 | 0.335222
5130 | 31122284 | 2665578.251 | 1212352.522 | 463.906 | 0 | 463906 | 1.93711 | 0.33537
5131 | 31122285 | 2665628.937 | 1212390.929 | 468.574 | 0 | 468574 | 1.94342 | 0.335412
5132 | 31121641 | 2665707.216 | 1212353.723 | 482.67 | 0 | 482670 | 1.90791 | 0.335177
5133 | 31124059 | 2665719.254 | 1212370.343 | 481.921 | Bolzen | 481921 | 1.9233 | 0.335283
5134 | 31121152 | 2665788.36 | 1212354.439 | 498.017 | 0 | 498017 | 1.91724 | 0.335244
5135 | 31122680 | 2665024.897 | 1212240.243 | 481.232 | 0 | 481232 | 1.93536 | 0.335366
5136 | 31121287 | 2665002.389 | 1212249.6 | 482.244 | 0 | 482244 | 1.91743 | 0.335252
5137 | 31124152 | 2665179.788 | 1212262.91 | 468.228 | 0 | 468228 | 1.92017 | 0.335263
5138 | 31124153 | 2665202.521 | 1212244.74 | 465.086 | 0 | 465086 | 1.91978 | 0.335264
5139 | 31121802 | 2665383.847 | 1212208.837 | 463.294 | 0 | 463294 | 1.9357 | 0.335365
5140 | 31124166 | 2665346.396 | 1212247.291 | 460.935 | 0 | 460935 | 1.93506 | 0.33536
5141 | 31121713 | 2665517.944 | 1212222.008 | 478.447 | 0 | 478447 | 1.91609 | 0.335237
5142 | 31121643 | 2665660.411 | 1212251.223 | 486.707 | 0 | 486707 | 1.92121 | 0.335268
5143 | 31121650 | 2665705.289 | 1212266.509 | 490.791 | Bolzen | 490791 | 1.93673 | 0.335371
5144 | 31121649 | 2665717.489 | 1212213.462 | 494.519 | Bolzen | 494519 | 1.92257 | 0.33528
5145 | 31121155 | 2665735.91 | 1212258.031 | 498.699 | 0 | 498699 | 1.91928 | 0.335254
5146 | 31124599 | 2665117.012 | 1212277.93 | 476.48 | Bolzen | 476480 | 1.89979 | 0.335129
5147 | 31124598 | 2665167.556 | 1212284.692 | 476.57 | Bolzen | 476570 | 1.9266 | 0.335304
5148 | 31124145 | 2665008.707 | 1212287.775 | 479.914 | 0 | 479914 | 1.91776 | 0.335247
5149 | 31121733 | 2665041.544 | 1212319.68 | 475.924 | Bolzen | 475924 | 1.91308 | 0.335218
5150 | 31124151 | 2665210.756 | 1212297.84 | 471.157 | 0 | 471157 | 1.90005 | 0.335129
5151 | 31122678 | 2665257.228 | 1212323.002 | 471.378 | Bolzen | 471378 | 1.9263 | 0.335296
5152 | 31122625 | 2665358.391 | 1212330.458 | 461.252 | Bolzen | 461252 | 1.93566 | 0.33536
5153 | 31121195 | 2665390.385 | 1212272.735 | 460.864 | 0 | 460864 | 1.93191 | 0.335336
5154 | 31121524 | 2665491.371 | 1212329.527 | 460.918 | 0 | 460918 | 1.9209 | 0.335265
5155 | 31121527 | 2665549.622 | 1212322.281 | 464.335 | 0 | 464335 | 1.92975 | 0.33532
5156 | 31124554 | 2664996.995 | 1212153.471 | 479.759 | 0 | 479759 | 1.92915 | 0.33532
5157 | 31124555 | 2664991.572 | 1212190.655 | 480.603 | 0 | 480603 | 1.93636 | 0.33537
5158 | 31124556 | 2664905.301 | 1212168.677 | 480.735 | 0 | 480735 | 1.9299 | 0.335326
5159 | 31124596 | 2665311.433 | 1212489.425 | 452.119 | 0 | 452119 | 1.92577 | 0.3353
5160 | 31124597 | 2665300.978 | 1212450.998 | 455.722 | 0 | 455722 | 1.93802 | 0.335379
5161 | 31124601 | 2665607.323 | 1212507.825 | 461.996 | Bolzen | 461996 | 1.93349 | 0.335348
5162 | 31124670 | 2665613.953 | 1212298.398 | 476.965 | Bolzen | 476965 | 1.94092 | 0.335395
5163 | 31124657 | 2665796.939 | 1212149.121 | 501.126 | Bolzen | 501126 | 1.92048 | 0.335261
